# Keil uVision project TorchSensor.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NRF24L01_screen +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\HARDWARE\ADXL345;.\HARDWARE\IIC;.\HARDWARE\TaskMgr;.\HARDWARE\TIMER;.\HARDWARE\USART2;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USER\TaskMgr;.\HARDWARE\NRF24L01;.\HARDWARE\SPI;.\USER;.\HARDWARE\CodeModule;.\HARDWARE\MLX90614;.\HARDWARE\UART4;.\USER\APP;.\HARDWARE\CAN;.\HARDWARE\FLASH;.\HARDWARE\ADC
  memory RVCT4: ROM 0x8000000 size 0x6400
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ../../../../../: DailyRecord.h NeverStopStudying.h
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/NRF24L01/: 24l01.c
    ./HARDWARE/SPI/: spi.c
    ./HARDWARE/FLASH/: stmflash.c
  group USER
    ./USER/TaskMgr/: TaskMgr.c
    ./USER/: main.c
    ./USER/APP/: UAPP_Comm.c UAPP_CAN.c
software components: CMSIS:CORE 3.30.0, CMSIS:DSP 1.4.2, Device:Startup 1.0.0
